Commit message: - rolling benchmark. 2 trials: one for error and another one for time.

File: res/bullet/Rolling/plane.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planeLink: geometry collision box size=50 50 10; visual box size=50 50 0.1
